# IAR project MARS-D_v1.ewp, settings and files
configuration MARS-D_v1 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx; __cplusplus
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ../Engine; ../USB; ../USB/Core; ../USB/USBMIDI
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: MARS-D_v1.hex
  ILINK.IlinkOutputFile: MARS-D_v1.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/Engine
    ../Engine/: bbd.cpp bbd.h CS43L22.c CS43L22.h cuveconv.cpp cuveconv.h dco.cpp dco.h display.c display.h engine.cpp engine.h fastmath.h hadsr.cpp hadsr.h kbd.cpp kbd.h lfo.cpp lfo.h matrix.cpp matrix.h midi.c midi.h onepole.h presetmngr.cpp presetmngr.h svf.cpp svf.h vibrato.cpp vibrato.h wtsawtooth.h wtsine.h wttriangle.h
    ../Src/: main.c
    ../Inc/: main.h
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f407xx.s
  group Application/USB
    ../USB/: usb_device.c usb_device.h usbd_conf.c usbd_conf.h usbd_desc.c usbd_desc.h usbd_midi.c usbd_midi.h usbd_midi_if.c usbd_midi_if.h
  group Application/USB/Core
    ../USB/Core/: usbd_core.c usbd_core.h usbd_ctlreq.c usbd_ctlreq.h usbd_def.h usbd_ioreq.c usbd_ioreq.h
  group Application/User
    ../Inc/: stm32f4xx_hal_conf.h stm32f4xx_it.h
    ../Src/: stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_usb.c
